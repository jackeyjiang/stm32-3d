# Keil uVision project melzi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: melzi +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,STM32_HIGH_DENSITY,SE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: .\inc;.\src;.\usb;.\lib\U8glib;.\std_maple;.\src\PRUSAI3;.\StLibraries\fatfs\src;.\StLibraries\STM32F10x_StdPeriph_Driver\inc;.\StLibraries\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x3f7ff
  memory RVCT5: ROM 0x803f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group system
    ./ST/: system_stm32f10x.c startup_stm32f10x_hd.s
  group usb
    ./StLibraries/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group u8g
    ./lib/U8glib/utility/: u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_io.c u8g_com_null.c u8g_cursor.c u8g_dev_gprof.c u8g_dev_null.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u8toa.c u8g_u16toa.c u8g_circle.c u8g_bitmap.c
    ./lib/U8glib/: U8glib.cpp
    ./src/PRUSAI3/: U8GLIB_ST7920_128X64_RRD.cpp
  group rl_sdfs
    ./lib/: SPI_STM32F103.c FS_CM3.lib Retarget.c File_Config.c
  group stdLib
    ./StLibraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_dma.c stm32f10x_usart.c
  group std maple
    ./std_maple/: m_adc.cpp m_gpio.cpp m_pins.cpp m_timer.cpp m_rcc.cpp m_Print.cpp m_serial.cpp m_usb.cpp m_sysConf.cpp m_usbSerial.cpp m_mapleInit.cpp m_nvic.cpp m_eep.cpp m_spi.cpp m_exti.cpp m_dma.cpp m_dac.cpp
  group project
    ./src/: main.cpp
    ./src/PRUSAI3/: stepMoto.cpp temperature.cpp Gcode.cpp Eeprom.cpp sdReader.cpp lcd.cpp commu.cpp
  group config
    ./src/: RTX_Conf_CM.c
    ./std_maple/: m_include.h sysConf.h
  group docment
    ./std_maple/: m_pins.h m_massStorage.h
    ../: ReadMe.txt
